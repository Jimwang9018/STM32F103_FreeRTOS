# Keil uVision project STM32-DEMO.uvproj, settings and files
target ADC1-DEMO (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --c99
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\FreeRTOS;..\FreeRTOS\include;..\HAL;..\STM32F10x_DSP_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c main.h imuTask.c bleSendTask.c bleReceiveTask.c ledTask.c keyTask.c motoTask.c powerTask.c wifiTask.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group HAL
    ../HAL/: usart1.c usart2.c usart3.c ble.c MPU9250.c led.c moto.c ADC.c I2C.c delay.c key.c tim.c power.c w25q256.c flashFunction.c esp8266.c imu.c fft.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group FreeRTOS\include
    ../FreeRTOS/include/: croutine.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group DSP_labrary
    ../STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_64_stm32.s
    ../STM32F10x_DSP_Lib/inc/: stm32_dsp.h table_fft.h
